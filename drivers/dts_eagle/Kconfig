## drivers/dts_eagle/Kconfig
```kconfig
config DTS_EAGLE
	tristate "DTS Eagle driver"
	depends on ARM64
	default y if ARM64
	help
	  DTS Eagle module.
```
